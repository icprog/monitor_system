# Keil uVision project 锂电容量测试仪.uvproj, settings and files
target Target 1 (MCS-51)
  device: SLH89F5162 SLH
  cpu: IRAM(0 - 0xFF) IROM(0-0xFFFF) XRAM(0-0x3FF) CLOCK(16600000)
  output: 20140103 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./src/: main.c lzf5162.c s6b3306.c ZI16.C
